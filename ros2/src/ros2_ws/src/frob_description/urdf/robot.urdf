Commit message: massive update, add navigation

File: ros2/src/ros2_ws/src/frob_description/urdf/robot.urdf (robot description, URDF)
Before this commit: robot frob, 8 links, 7 joints
Joints:
- joint laser_to_lidar: origin xyz=0 0 0 rpy=0 0 1.5708 -> xyz=0 0 0 rpy=0 0 3.141592

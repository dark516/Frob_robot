Commit message: update slam, odom (need test) and add bringup.launch

File: ros2/src/ros2_ws/src/description/urdf/robot.urdf (robot description, URDF)
Before this commit: robot frob, 8 links, 7 joints
Joints:
- joint laser_to_lidar: origin xyz=0 0 0 rpy=0 0 -1.570796325 -> xyz=0 0 0 rpy=0 0 1.5708
